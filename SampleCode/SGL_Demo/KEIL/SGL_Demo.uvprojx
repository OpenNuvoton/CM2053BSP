# Keil uVision project SGL_Demo.uvprojx, settings and files
target SGL_Demo (6240000::V6.24::ARMCLANG)
  device: CM2053EL8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: SGL_Demo
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\CM2053\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\sgl;..\..\..\ThirdParty\sgl\include;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\Library\Device\Nuvoton\CM2053\Source\ARM\APROM.sct
  group CMSIS
    ../../../Library/Device/Nuvoton/CM2053/Source/: system_CM2053.c
    ../../../Library/Device/Nuvoton/CM2053/Source/ARM/: startup_CM2053.c
  group User
    ../: main.c tft.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c uart.c spi.c gpio.c sys.c pdma.c
  group sgl
    ../../../ThirdParty/sgl/core/: sgl_anim.c sgl_core.c sgl_event.c sgl_log.c sgl_math.c sgl_misc.c sgl_snprintf.c
    ../../../ThirdParty/sgl/draw/: sgl_draw_arc.c sgl_draw_circle.c sgl_draw_icon.c sgl_draw_line.c sgl_draw_rect.c sgl_draw_ring.c sgl_draw_text.c
    ../../../ThirdParty/sgl/fonts/: sgl_ascii_song23.c FontAwesome_23.c iconfont_23.c
    ../../../ThirdParty/sgl/mm/lwmem/: lwmem.c sgl_mm.c
    ../../../ThirdParty/sgl/widgets/button/: sgl_button.c
    ../../../ThirdParty/sgl/widgets/arc/: sgl_arc.c
    ../../../ThirdParty/sgl/widgets/checkbox/: sgl_checkbox.c
    ../../../ThirdParty/sgl/widgets/circle/: sgl_circle.c
    ../../../ThirdParty/sgl/widgets/icon/: sgl_icon.c
    ../../../ThirdParty/sgl/widgets/label/: sgl_label.c
    ../../../ThirdParty/sgl/widgets/line/: sgl_line.c
    ../../../ThirdParty/sgl/widgets/msgbox/: sgl_msgbox.c
    ../../../ThirdParty/sgl/widgets/rectangle/: sgl_rectangle.c
    ../../../ThirdParty/sgl/widgets/ring/: sgl_ring.c
    ../../../ThirdParty/sgl/widgets/slider/: sgl_slider.c
    ../../../ThirdParty/sgl/widgets/switch/: sgl_switch.c
    ../../../ThirdParty/sgl/widgets/textbox/: sgl_textbox.c
    ../../../ThirdParty/sgl/widgets/textline/: sgl_textline.c
    ../../../ThirdParty/sgl/widgets/keyboard/: sgl_keyboard.c
    ../../../ThirdParty/sgl/widgets/ext_img/: sgl_ext_img.c
