# Keil uVision project USBD_Audio_Codec.uvprojx, settings and files
target USBD_Audio_Codec (6240000::V6.24::ARMCLANG)
  device: CM2053EL8AE Nuvoton
  pack: Nuvoton.NuMicroCM_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: USBD_Audio_Codec
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\CM2053\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\CM2053\Source\ARM\APROM.sct
  link misc: --pd="-DFLASH_SIZE=0x8000 -DSRAM_SIZE=0x4000 -DSTACK_SIZE=0x400 -DHEAP_SIZE=0x400"
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2053/Source/: system_CM2053.c
    ../../../../Library/Device/Nuvoton/CM2053/Source/ARM/: startup_CM2053.c
  group User
    ../: descriptors.c main.c usbd_audio.c config_pdma.c audio_codec.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c i2c.c gpio.c uart.c spi.c pdma.c timer.c
