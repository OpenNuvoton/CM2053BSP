# Keil uVision project FMC_IAP_LDROM.uvprojx, settings and files
target FMC_IAP_LDROM (6240000::V6.24::ARMCLANG)
  device: CM2053EL8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_IAP_LDROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\CM2053\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\CM2053\Source\ARM\LDROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2053/Source/: system_CM2053.c
    ../../../../Library/Device/Nuvoton/CM2053/Source/ARM/: startup_CM2053.c
  group User
    ../: FMC_IAP_LDROM.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c
