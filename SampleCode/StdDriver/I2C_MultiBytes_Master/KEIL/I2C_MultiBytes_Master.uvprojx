# Keil uVision project I2C_MultiBytes_Master.uvprojx, settings and files
target I2C_MultiBytes_Master (6240000::V6.24::ARMCLANG)
  device: CM2053EL8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: I2C_MultiBytes_Master
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\CM2053\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\CM2053\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2053/Source/: system_CM2053.c
    ../../../../Library/Device/Nuvoton/CM2053/Source/ARM/: startup_CM2053.c
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c i2c.c retarget.c sys.c gpio.c
